FILESEXTRAPATHS_prepend := "${THISDIR}/linux-obmc:"
SRC_URI += "file://vesnin.cfg"
SRC_URI += "file://0001-Vesnin-patch.patch"
